# Keil uVision project usb_dev_bulk.uvproj, settings and files
target usb_dev_bulk (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ELITTLE
  output: usb_dev_bulk
  c flags: Optim=1 uC99=1
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1 UART_BUFFERED
  c include: ..\..\..\USB;..\..\usb_dev_bulk;..\inc;..\driverlib;..\project;..\utils;..\usblib
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../user/: usb_bulk_structs.c usb_bulk_structs.h usb_dev_bulk.c
  group driverlib
    ../driverlib/: driverlib.lib
  group inc
    ../inc/: asmdefs.h hw_adc.h hw_aes.h hw_can.h hw_ccm.h hw_comp.h hw_des.h hw_eeprom.h hw_emac.h hw_epi.h hw_fan.h hw_flash.h hw_gpio.h hw_hibernate.h hw_i2c.h hw_ints.h hw_lcd.h hw_memmap.h hw_nvic.h hw_pwm.h hw_qei.h hw_shamd5.h hw_ssi.h hw_sysctl.h hw_sysexc.h hw_timer.h hw_types.h hw_uart.h hw_udma.h hw_usb.h hw_watchdog.h tm4c123gh6pm.h
  group startup
    ../start-up/: startup_rvmdk.S
  group utils
    ../utils/: uartstdio.c ustdlib.c
  group usblib
    ../usblib/: usblib.lib
