# Keil uVision project LCD-FONT.uvproj, settings and files
target LCD-FONT (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ELITTLE
  output: LCD-FONT +hex
  c flags: Optim=1
  c define: rvmdk PART_TM4C123GH6PM USE_DY_PB_2 USE_DY_PB_3 USE_DY_PB_FINAL
  c include: ..\..\..\LCD;..\..\lcd-font;..\user;..\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../user/: gt20l16s1y.c gt20l16s1y.h hw_gt20l16s1y.h hw_uc1701.h m4_common.h m4_config.h m4_lcd.c m4_pinmux.c m4_pinmux.h uc1701.c uc1701.h main.c
  group driverlib
    ../driverlib/: driverlib.lib
  group inc
    ../inc/: asmdefs.h hw_adc.h hw_aes.h hw_can.h hw_ccm.h hw_comp.h hw_des.h hw_eeprom.h hw_emac.h hw_epi.h hw_fan.h hw_flash.h hw_gpio.h hw_hibernate.h hw_i2c.h hw_ints.h hw_lcd.h hw_memmap.h hw_nvic.h hw_pwm.h hw_qei.h hw_shamd5.h hw_ssi.h hw_sysctl.h hw_sysexc.h hw_timer.h hw_types.h hw_uart.h hw_udma.h hw_usb.h hw_watchdog.h tm4c123gh6pm.h
  group start-up
    ../start-up/: startup_rvmdk.S
