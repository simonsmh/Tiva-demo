# IAR project Backup (2) of M4MP3.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_DY_PB_2; USE_MAX232; USE_UC1705; USE_LM75A; ewarm; PART_TM4C123GH6PM; TARGET_IS_BLIZZARD_RB1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: C:\ti\TivaWare_C_Series-2.0.1.11577
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: M4MP3.bin
  ILINK.IlinkOutputFile: M4MP3.out
  ILINK.IlinkIcfFile: M4MP3.icf
  ILINK.IlinkAdditionalLibs: C:\ti\TivaWare_C_Series-2.0.1.11577\driverlib\rvmdk\driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group board
    ./: m4_pinmux.c startup_ewarm.c
  group driver
    ./: dac7512.c gt20l16s1y.c lm75a.c sdc.c tlv320aic23b.c tmp100.c uc1701.c
  group fatfs
    FatFs/: ff.c
  group header
    ./: dac7512.h gt20l16s1y.h hw_gt20l16s1y.h hw_tmp100.h hw_uc1701.h lm75a.h m4_common.h m4_config.h m4_pinmux.h tlv320aic23b.h tmp100.h uc1701.h
  group main
    ./: m4_adc.c m4_app.c m4_codec.c m4_dac.c m4_gpio.c m4_i2c.c m4_lcd.c m4_main.c m4_spwm.c m4_ssi.c m4_temp.c m4_uart.c
