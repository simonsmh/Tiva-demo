# Keil uVision project driverlib.uvproj, settings and files
target driverlib (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: driverlib (library)
  c flags: Optim=3 oTime=1 OneElfS=1 wLevel=2
  c define: rvmdk
  c misc: --c99
  c include: ..;
  library: MicroLIB
  group Source
    ./: adc.c can.c comp.c cpu.c eeprom.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c mpu.c pwm.c qei.c ssi.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group Documentation
    ./: readme.txt
